# Keil uVision project SPS30_STM32F1.uvprojx, settings and files
target STM32-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPS30_STM32F1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER
  c include: .\Source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./Source/: startup_stm32f10x_md_vl.s
  group Source Files
    ./Source/: main.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
software components: CMSIS:CORE 4.3.0
